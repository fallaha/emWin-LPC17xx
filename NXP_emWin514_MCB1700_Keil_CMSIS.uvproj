# Keil uVision project NXP_emWin514_MCB1700_Keil_CMSIS.uvproj, settings and files
target Debug_FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Start_LPC1769_MCB1700_KEIL_CMSIS +hex
  c flags: Optim=1
  c define: DEBUG=1
  c misc: --diag_suppress=951
  c include: Application;Config;GUI;Inc;System\HW;System\HW\DeviceSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --diag_suppress=6329 --diag_suppress=6314
  group Config
    ./Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h SIMConf.c AsciiLib.c GLCD.c HzLib.c
    ./: NXP_emWin514_MCB1700_Keil_CMSIS.c
  group GUI
    ./GUI/: GUI_CM3.lib
  group Inc
    ./Inc/: BSP.h JLINKMEM.h SEGGER.h TaskPrio.h
  group Doc
    ./: ReadMe.txt
  group System
    ./System/HW/: HWConf.c HWConf.h LCD_X_SPI.h
    ./System/HW/DeviceSupport/: LPC17xx.h
    ./System/: Main.cpp
  group Application
    ./Application/: Main_app.cpp toolsDLG.cpp UART.cpp SDcard.cpp editor.cpp FILEShow.cpp
  group lib
    ./MouseKeyboard/libraries/CDL/keil_output/: CDL_LPC17xx.lib
    ./MouseKeyboard/libraries/LPCUSBLib/keil_output/: LPCUSBlib_LPC17xx_Host.lib
  group UART
    ./AF_UART_LIB/: AF_CPU.cpp AF_FLCD.cpp AF_string.cpp UART.cpp
  group LCD
    ./AF_LCD_LIB/: AF_LCD.cpp
  group keyboardMouse
    ./MouseKeyboard/: KeyboardHost.cpp
  group SD
    ./AF_SD_LIB/: File_Config.c SPI_LPC17xx.c Retarget.c Serial.c FS_CM3.lib
target Release_FLASH (ARM-ADS)
  device: LPC1768 NXP
  cpu: as above
  output: Start_LPC1769_MCB1700_KEIL_CMSIS +hex
  c flags: Optim=1 oTime=1
  c define: __LPC17XX__ USB_HOST_ONLY
  c misc: --diag_suppress=951 --gnu --diag_suppress=1207,2776
  c include: Application;Config;GUI;Inc;System\HW;System\HW\DeviceSupport;.\MouseKeyboard\libraries\LPCUSBLib\Drivers\USB;.\MouseKeyboard\libraries\BSP;.\MouseKeyboard\libraries\CDL\LPC17xxLib\inc;.\MouseKeyboard\libraries\LPCUSBLib\Drivers\USB\Class\Common;.\FlashFS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --diag_suppress=6329 --diag_suppress=6314
