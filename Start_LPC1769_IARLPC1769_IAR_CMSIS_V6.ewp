# IAR project Start_LPC1769_IARLPC1769_IAR_CMSIS_V6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG=1; __inline=inline
  ICCARM.CCIncludePath2: Application; Config; GUI; Inc; System\HW; System\HW\DeviceSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Start_LPC1769_IARLPC1769_IAR_CMSIS_V6.srec
  ILINK.IlinkOutputFile: Start_LPC1769_IAR_CMSIS.out
  ILINK.IlinkIcfFile: System\HW\Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  ICCARM.CCDefines: DEBUG=0
  ICCARM.CCIncludePath2: Application; Config; GUI; Inc; Setup
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Start_LPC1788_IARLPC1788_IAR_CMSIS_V6.srec
  ILINK.IlinkOutputFile: Start_LPC1788_IAR_CMSIS.out
  ILINK.IlinkIcfFile: Setup\LPC1788_IAR_LPC1788-SK_Flash.icf
  group Application
    Application/: GUI_WIDGET_GraphXYDemo.c
  group Config
    Config/: Global.h GUI_X.c GUIConf.c GUIConf.h LCDConf.c SysConf.h
    Setup/: LCDConf.h
  group Doc
    ./: ReadMe.txt
  group GUI
    GUI/: BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h emWin_514_IAR630_M3_LE.a FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_Lin.h GUIDRV_Lin_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Intern_ConfDep.h
  group Inc
    Inc/: BSP.h JLINKDCC.h JLINKMEM.h SEGGER.h TaskPrio.h
  group System
    System/: Main.c
  group System/HW
    System/HW/: HWConf.c HWConf.h LCD_X_SPI.c LCD_X_SPI.h
  group System/HW/DeviceSupport
    System/HW/DeviceSupport/: startup_LPC17xx_IAR.s system_LPC17xx.c
