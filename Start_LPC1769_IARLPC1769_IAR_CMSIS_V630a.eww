<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Start_LPC1769_IARLPC1769_IAR_CMSIS_V6.ewp</path>
  </project>
  <batchBuild/>
</workspace>


